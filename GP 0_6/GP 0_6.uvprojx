# Keil uVision project GP 0_6.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114FHN33/202 NXP
  pack: Keil.LPC1100_DFP.1.3.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GP 0_6
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: RAM_BASE=0x10000000 RAM_SIZE=0x1000 STACK_SIZE=0x200 MAX_LIBRARY_NUMBER=16 BYTES_PER_SECTOR=512 SECTOR_PER_CLUSTER=2 NUMBER_OF_FATS=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group hardware\lpc1114
    ./os/hardware/lpc1114/: boot.s lpc1114.cpp
  group system
    ./os/system/: system.cpp
  group devices
    ./os/devices/: device.cpp
  group process
    ./os/process/: process.cpp
  group filesys
    ./os/filesys/: filesys.cpp
  group memory
    ./os/memory/: memory.cpp
